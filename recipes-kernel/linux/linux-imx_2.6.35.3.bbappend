
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_olinuxino = "olinuxino"

SRC_URI += "file://olinuxino.patch \
          "